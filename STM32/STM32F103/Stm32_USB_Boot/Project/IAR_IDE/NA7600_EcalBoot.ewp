# IAR project NA7600_EcalBoot.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\inc; ..\..\Libraries\USB\Configure\inc; ..\..\Libraries\USB\Core\inc; ..\..\MySystem\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: NA7600_EcalBoot.bin
  ILINK.IlinkOutputFile: NA7600_EcalBoot.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries/CMSIS/inc
    ../../Libraries/CMSIS/inc/: core_cm3.h stm32f10x.h system_stm32f10x.h
  group Libraries/CMSIS/src
    ../../Libraries/CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Libraries/CMSIS/startup
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group Libraries/STM32F10x_StdPeriph_Driver/inc
    ../../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries/STM32F10x_StdPeriph_Driver/src
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Libraries/USB/Configure/inc
    ../../Libraries/USB/Configure/inc/: hw_config.h platform_config.h stm32_it.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
  group Libraries/USB/Configure/src
    ../../Libraries/USB/Configure/src/: hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Libraries/USB/Core/inc
    ../../Libraries/USB/Core/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group Libraries/USB/Core/src
    ../../Libraries/USB/Core/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group MySystem/inc
    ../../MySystem/inc/: delay.h myusart.h sys.h
  group MySystem/src
    ../../MySystem/src/: delay.c myusart.c sys.c
  group Project
    ../: ConstValue.c ConstValue.h JumpToCode.c JumpToCode.h led.c led.h main.c Stm32_InterFlash.c Stm32_InterFlash.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h USB_Communication.c USB_Communication.h
