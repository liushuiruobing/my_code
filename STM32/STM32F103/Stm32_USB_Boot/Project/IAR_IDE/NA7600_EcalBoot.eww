<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NA7600_EcalBoot.ewp</path>
  </project>
  <batchBuild/>
</workspace>


